# KOMPAS-3D part (ZARDP 100.063.27.P.m3d)

Model tree:
1. Операция без истории:1  (labels: ЗАРДП 100.063.27)

Texts:
  ЗАРДП 100.063.27-Р
  ЗАРДП 100.063.27